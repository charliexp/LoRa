# Keil uVision project Lora Board.uvprojx, settings and files
target Gateway sx1272mb2das (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Gateway +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L073xx, USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER, USE_BAND_868,USE_MODEM_LORA,GATEWAY
  c misc: --C99
  c include: .\Implementation\LoRa Board\inc;.\Implementation\LoRa Board\Drivers\BSP\STM32L0xx_Nucleo;.\Implementation\LoRa Board\Drivers\STM32L0xx_HAL_Driver\Inc;.\Implementation\LoRa Board\Drivers\CMSIS\Device\ST\STM32L0xx\Include;.\Implementation\LoRa Board\Drivers\CMSIS\Include;.\Implementation\LoRa Board\Middlewares\Third_Party\Lora\Crypto;.\Implementation\LoRa Board\Middlewares\Third_Party\Lora\Mac;.\Implementation\LoRa Board\Middlewares\Third_Party\Lora\Phy;.\Implementation\LoRa Board\Middlewares\Third_Party\Lora\Utilities;.\Implementation\LoRa Board\Drivers\BSP\X_NUCLEO_IKS01A1;.\Implementation\LoRa Board\Drivers\BSP\Components\Common;.\Implementation\LoRa Board\Drivers\BSP\Components\hts221;.\Implementation\LoRa Board\Drivers\BSP\Components\lps25hb;.\Implementation\LoRa Board\Drivers\BSP\Components\sx1272;.\Implementation\LoRa Board\Middlewares\Third_Party\Lora\Core;.\Implementation\LoRa Board\Drivers\BSP\sx1272mb2das
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Drivers/BSP/Components
    Implementation/LoRa Board/Drivers/BSP/Components/sx1272/: sx1272.c
  group Drivers/BSP/sx1272mb2das
    Implementation/LoRa Board/Drivers/BSP/sx1272mb2das/: sx1272mb2das.c
  group Drivers/CMSIS
    Implementation/LoRa Board/Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    Implementation/LoRa Board//Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
    Implementation/LoRa Board/Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c
  group Middlewares/Lora/Utilities
    Implementation/LoRa Board/Middlewares/Third_Party/Lora/Utilities/: delay.c timeServer.c utilities.c low_power_manager.c
  group MDK_ARM
    Implementation/LoRa Board/MDK_ARM/: startup_stm32l073xx.s
  group src
    Implementation/LoRa Board/src/: compensator.c debug.c eeprom.c hw_gpio.c hw_i2c.c hw_rtc.c hw_spi.c hw_uart.c lora.c main.c message.c meter.c pc.c stm32l0xx_hal_msp.c stm32l0xx_hw.c stm32l0xx_it.c vcom.c
target End node sx1272mb2das (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: as above
  output: End node +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L073xx, USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER, USE_BAND_868,USE_MODEM_LORA,END_NODE
  c misc: --C99
  c include: .\Implementation\LoRa Board\inc;.\Implementation\LoRa Board\Drivers\BSP\STM32L0xx_Nucleo;.\Implementation\LoRa Board\Drivers\BSP\Components\Common;.\Implementation\LoRa Board\Drivers\BSP\Components\sx1272;.\Implementation\LoRa Board\Drivers\BSP\sx1272mb2das;.\Implementation\LoRa Board\Drivers\CMSIS\Include;.\Implementation\LoRa Board\Drivers\CMSIS\Device\ST\STM32L0xx\Include;.\Implementation\LoRa Board\Drivers\STM32L0xx_HAL_Driver\Inc;.\Implementation\LoRa Board\Middlewares\Third_Party\Lora\Phy;.\Implementation\LoRa Board\Middlewares\Third_Party\Lora\Utilities;.\Implementation\LoRa Board\Middlewares\Third_Party\Power LoRa\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
